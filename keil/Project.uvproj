# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: Project +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Libary\Device\CMS8S6990\Include;..\Libary\StdDriver\inc;..\code
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS8S6990/Include/: cms8s6990.h
    ../Libary/Device/CMS8S6990/: startup_cms8s6990.A51
  group LIB
    ../Libary/StdDriver/src/: acmp.c adc.c epwm.c extint.c flash.c gpio.c i2c.c lse.c opa.c pga.c spi.c system.c timer.c uart.c wdt.c
  group User
    ../code/: isr.c main.c common.c hm5841v.c display.c ht1621b.c key.c led.c buzzer.c power.c settings.c alarm.c plc.c fan.c
